include arb2-image.bb
DESCRIPTION = "ARB2 base initramfs image"

IMAGE_FSTYPES = "${INITRAMFS_FSTYPES}"
PACKAGE_INSTALL = "${IMAGE_INSTALL}"




