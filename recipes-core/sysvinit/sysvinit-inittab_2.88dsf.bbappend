FILESEXTRAPATHS_append := "${THISDIR}/files:"

# Add ttymxc4 to rc_mxc.S
SRC_URI += "file://rc_mxc.S"