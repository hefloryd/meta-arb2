FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
 
SRC_URI += "file://0001-arb2-add-board.patch"
SRC_URI += "file://0002-arb2-do-not-reset-board.patch"

